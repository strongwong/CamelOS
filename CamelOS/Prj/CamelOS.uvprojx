# Keil uVision project CamelOS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: CamelOS
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\CamelRTOS\inc;..\CamelRTOS\portable\RVDS\ARM_CM3;..\User\inc;..\CamelExample\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../User/: main.c
  group CamelExample
    ../CamelExample/: CreatList.c TaskSwitching.c
  group CamelOS/Ports
    ../CamelRTOS/portable/RVDS/ARM_CM3/: camel_port.c
  group CamelOS/Src
    ../CamelRTOS/: camel_list.c camel_task.c
  group Doc
    ../Doc/: Readme.md
software components: CMSIS:CORE 5.2.0, Device:Startup 1.1.0
